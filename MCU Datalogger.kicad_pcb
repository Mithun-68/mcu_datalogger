# Repository Mithun-68/mcu_datalogger

File README.md:

# MCU Datalogger (KiCad Project)

A custom MCU-based datalogger board designed in **KiCad 10.0**. This project was built as part of the **PCB Design with KiCad by Peter Dalmaris** course on Udemy to practice real-world schematic capture, PCB layout, and multi-layer board design.

The board reads sensor data and saves timestamped logs to external non-volatile memory using a Real-Time Clock (RTC).

---

## Screenshots & Renders

### 4-Layer Board

*Final 3D Render of 4-layer design with dedicated inner GND and Power planes.*

### 2-Layer vs. 4-Layer Evolution
I initially routed this board on 2 layers and later updated it to a 4-layer stackup to improve power distribution and signal integrity. Both versions are preserved in the Git history:

* **`main` / `4-layer` branch:** Final production layout using a 4-layer stackup (Top / GND Plane / VCC Plane / Bottom).
* **`2-layer` branch:** Original 2-layer prototype with routed power traces.

*2-Layer PCB Layout with Red Tracks as Front Copper and Blue Tracks as Back Copper.*

### Schematic

*Schematic of the MCU Datalogger in KiCad 10.0*
  
---

## Main Features & Components

* **Microcontroller:** Core MCU to manage sensors and memory logging.
* **Real-Time Clock (RTC):** Dedicated RTC chip with battery backup for accurate timestamping.
* **Non-Volatile Memory:** External memory chip to safely retain logs during power-down.
* **Power Net Class:** Custom net class rules applied to `/VCC` and `GND` traces for wider power routing and proper clearances.
* **4-Layer Stackup:** Continuous inner Ground plane (Layer 2) and Power plane (Layer 3) to keep power clean and noise low.

---

### Manufacturing & Design Trade-offs (PCBWay Quote Comparison)

I quoted both board designs on **pcbway.com** (52.83 mm × 34.31 mm standard options, 5 pcs) to evaluate cost versus performance:

* **2-Layer Board:** **~$5.00**
  * **Pros:** Extremely cheap to manufacture, fast prototyping turnaround, fine for simple low-speed routing, and quick manufacturing (~24 hours).
  * **Cons:** Harder to route clean power/GND return paths, higher potential for noise and EMI.
* **4-Layer Board:** **~$31.16**
  * **Pros:** Solid internal `GND` and `VCC` planes provide excellent signal integrity, low-noise power delivery, and easier trace routing.
  * **Cons:** Over 6x higher manufacturing cost, slightly longer production lead times (~4-5 days).

**Conclusion:** The 2-layer version is great for a budget prototype, but the 4-layer stackup is worth the extra cost for a production board to ensure stable MCU and memory operation.

---

## Acknowledgements & Course Credit

This project was built following the **PCB Design with KiCad by Peter Dalmaris** course on Udemy. 

**Key skills practiced:**
* Schematic capture and footprint assignment in KiCad 10.0.
* Routing 2-layer and 4-layer PCB stackups.
* Setting up custom Net Classes for power rails.
* Managing EDA files and PCB branch merges using Git and GitHub Desktop.

---

**Designed by Mithun**

## KiCad design MCU Datalogger.kicad_pcb

Parts:
BT1: Battery; PinHeader_1x02_P2.54mm_Vertical
C1, C4: 0.1uF; C_0805_2012Metric
C2, C3: 22pF; C_0805_2012Metric
C5: 100nF; C_0805_2012Metric
D1, D2: LED; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.1mm
R1, R2, R6: 10K; R_0805_2012Metric
R3, R4: 4.7K; R_0805_2012Metric
R5, R7: 330; R_0805_2012Metric
U1, U3: 24LC1025; SOIC-8_5.3x5.3mm_P1.27mm
U2: DS1337S_; SOIC127P600X175-8N
U4: ATMEGA328P-AU; QFP80P900X900X120-32N; PARTREV 8271A
Y1: 32.768 KHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering
Y2: 16 MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering

Connections:
/D2: U4.32 (PD2); also elsewhere on the board
/D3: U4.1 (PD3); also elsewhere on the board
/D4: U4.2 (PD4); also elsewhere on the board
/D5: U4.9 (PD5); also elsewhere on the board
/D6: U4.10 (PD6); also elsewhere on the board
/D7: U4.11 (PD7); also elsewhere on the board
/D8: U4.12 (PB0); also elsewhere on the board
/MISO: U4.16 (PB4); also elsewhere on the board
/MOSI: U4.15 (PB3); also elsewhere on the board
/RESET: R6.2, U4.29 (PC6/~RESET); also elsewhere on the board
/RX: U4.30 (PD0); also elsewhere on the board
/SCK: D1.2 (A), U4.17 (PB5); also elsewhere on the board
/SCL: R3.2, U1.6 (SCL), U2.6 (SCL), U3.6 (SCL), U4.28 (PC5); also elsewhere on the board
/SDA: R4.1, U1.5 (SDA), U2.5 (SDA), U3.5 (SDA), U4.27 (PC4); also elsewhere on the board
/TX: U4.31 (PD1); also elsewhere on the board
/VCC: BT1.1 (+), C1.2, C5.1, D2.2 (A), R1.1, R2.1, R3.1, R4.2, R6.1, U1.1 (A0), U1.2 (A1), U1.3 (A2), U1.8 (VCC), U2.8 (VCC), U3.1 (A0), U3.3 (A2), U3.8 (VCC), U4.4 (VCC), U4.18 (AVCC); also elsewhere on the board
GND: BT1.2 (-), C1.1, C2.2, C3.1, C4.1, C5.2, R5.1, R7.2, U1.4 (GND), U1.7 (WP), U2.4 (GND), U3.2 (A1), U3.4 (GND), U3.7 (WP), U4.3 (GND), U4.5 (GND), U4.21 (GND); also elsewhere on the board
unnamed: D1.1 (K), R5.2
unnamed: D2.1 (K), R7.1
unnamed: R2.2, U2.7 (SQW/~INT)
unnamed: U2.1 (X1), Y1.2
unnamed: U2.2 (X2), Y1.1
unnamed: R1.2, U2.3 (~INTA)
unnamed: C4.2, U4.20 (AREF)
unnamed: C2.1, U4.7 (PB6), Y2.2
unnamed: C3.2, U4.8 (PB7), Y2.1

Notes on the sheet:
Mounting
MCU
EEPROM
Real-time Clock

Parts:
J1, J3: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J2: Conn_01x09_Pin; PinHeader_1x09_P2.54mm_Vertical
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical

Connections:
/D2: J2.1; also elsewhere on the board
/D3: J2.2; also elsewhere on the board
/D4: J2.3; also elsewhere on the board
/D5: J2.4; also elsewhere on the board
/D6: J2.5; also elsewhere on the board
/D7: J2.6; also elsewhere on the board
/D8: J2.7; also elsewhere on the board
/MISO: J4.1; also elsewhere on the board
/MOSI: J4.4; also elsewhere on the board
/RESET: J4.5; also elsewhere on the board
/RX: J3.3; also elsewhere on the board
/SCK: J4.3; also elsewhere on the board
/SCL: J1.4; also elsewhere on the board
/SDA: J1.3; also elsewhere on the board
/TX: J3.4; also elsewhere on the board
/VCC: J1.2, J2.9, J3.2, J4.2; also elsewhere on the board
GND: J1.1, J2.8, J3.1, J4.6; also elsewhere on the board

Board: 4 copper layers, 52.8 x 34.3 mm, 30 parts (1 on the bottom side), 26 nets.

Other parts of the board:
REF1: KiCad-Logo2_5mm_SilkScreen
